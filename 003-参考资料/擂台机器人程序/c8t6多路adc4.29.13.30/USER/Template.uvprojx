# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\HARDWARE\lcd;..\SYSTEM\delay;..\SYSTEM\window;..\HARDWARE\mpu9250;..\SYSTEM\sys;..\SYSTEM\timer;..\SYSTEM\usart;..\HARDWARE\dac;..\HARDWARE\steer;..\SOFTWARE\PID
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: stm32f10x_it.c main.c system_stm32f10x.c interrupt.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTERM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/window/: window.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/timer/: timer.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/lcd/: lcd.c
    ../HARDWARE/mpu9250/: mpu9250.c
    ../HARDWARE/dac/: dac.c
    ../HARDWARE/steer/: steer.c
    ./spi/: spi.c spi.h
    ./NRF24L01/: 24l01.c 24l01.h
    ./GPIO/: GPIO.c GPIO.h
    ./ADC/: adc.c adc.h
  group SOFTWARE
    ../SOFTWARE/PID/: pid.c
